Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: Project Number
Time: 2025-01-07T15:02:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.30.74 - Exporter 21.1.30.74 - Alternate UI 21.1.30.74
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 07 15:02:13 2025 * Host: LIS-C-001JH * Database: C:\Users\MEJ3OVR\AppData\Local\Temp\7aa0a78d-7ddc-457c-bf33-5315ad8bb105\f838a14d-ebf2-4e22-a167-50063bf707d8\ifc * Database version: 5507 * Database creation date: Tue Jan 07 15:02:12 2025 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Jan 07 15:02:13 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 07 15:02:13 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -1, -58, -789672; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 2
LongName: Level 2; Elevation: 3000 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_BuildingStoreyCommon - Reference: 8mm Head
Constraints - Elevation: 3000 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 2; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Intrusion-Products_Bosch_Reader, OSDP, white_ARD-SELECT-WO:Reader, OSDP, white_ARD-SELECT-WO, Intrusion-Products_Bosch_Reader, OSDP, white_ARD-SELECT-WO:Reader, OSDP, white_ARD-SELECT-WO:423112
In: Level 2
Type - Material: White_Glass_Screen, Body_Gray
Type - Constraints - Crypt_OSDP: yes; Default Elevation: 1400 mm
Type - Dimensions - Dimension depth (mm): 35; Dimension height (mm): 88; Dimension width (mm): 101
Type - Electrical - Operating voltage (VDC) (maximum): 30; Operating voltage (VDC) (minimum): 8; Power consumption (VA): 3.50
Type - General - IP Class: IP54; Operating temperature (°C) (maximum): 60; Operating temperature (°C) (minimum): -25
Type - Identity Data - Description: Engineered Solutions - LECTUS select LECTUS select u Compact design u Easy installation u Sabotage monitoring u Numbers and symbols backlighted u Three status LEDs The LECTUS select line consists of two different reader variants, one with keypad and one without keypad.; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/LECTUS_Installation_Manual_enUS_84333123083.pdf; Manufacturer: Bosch Security and Safety Systems; OmniClass Number: 23.85.30.11; OmniClass Title: Access Controls; PlanningTools: N/A; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/LECTUS_select_Data_sheet_enUS_84333059723.pdf; Product Website: https://commerce.boschsecurity.com/nordics/en/LECTUS-select/p/F.01U.389.840/; Type Name: Reader, OSDP, white_ARD-SELECT-WO
Type - Materials and Finishes - Color: White/silver; Color in RAL: N/A; Screen_Material: White_Glass_Screen
Type - Other - Category: Security Devices; Family Name: Intrusion-Products_Bosch_Reader, OSDP, white_ARD-SELECT-WO
Type - Pset_BuildingElementProxyCommon - Reference: Reader, OSDP, white_ARD-SELECT-WO; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: Reader, OSDP, white_ARD-SELECT-WO
Type - Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Material: Body_Gray
Constraints - Elevation from Level: 0 mm; Host: Level : Level 2; Level: Level: Level 2; Schedule Level: Level: Level 2
Construction - ARA-SELECT-SWA Wallmount Box Lectus Select, silver: no; ARA-SELECT-WWA Wallmount Box Lectus Select, white: no
Dimensions - Area: 0.011458 m2; Volume: 0.000152288 m3
Electrical - Circuiting - Electrical Data: 0 V/1-0 VA
Identity Data - CTN: ARD-SELECT-WO; Mark: 4; Material number: F.01U.389.840
Other - Family: Intrusion-Products_Bosch_Reader, OSDP, white_ARD-SELECT-WO: Reader, OSDP, white_ARD-SELECT-WO; Family and Type: Intrusion-Products_Bosch_Reader, OSDP, white_ARD-SELECT-WO: Reader, OSDP, white_ARD-SELECT-WO; Type: Intrusion-Products_Bosch_Reader, OSDP, white_ARD-SELECT-WO: Reader, OSDP, white_ARD-SELECT-WO; Type Id: Intrusion-Products_Bosch_Reader, OSDP, white_ARD-SELECT-WO: Reader, OSDP, white_ARD-SELECT-WO
Phasing - Phase Created: New Construction

# IfcDistributionPort, Port_423112
Description: Flow; FlowDirection: SOURCEANDSINK
