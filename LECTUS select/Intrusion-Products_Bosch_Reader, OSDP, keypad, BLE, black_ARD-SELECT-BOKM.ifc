Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: Project Number
Time: 2025-01-07T14:58:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.30.74 - Exporter 21.1.30.74 - Alternate UI 21.1.30.74
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 07 14:58:26 2025 * Host: LIS-C-001JH * Database: C:\Users\MEJ3OVR\AppData\Local\Temp\7aa0a78d-7ddc-457c-bf33-5315ad8bb105\6713e158-0270-4765-be5f-9e830b7e966e\ifc * Database version: 5507 * Database creation date: Tue Jan 07 14:58:26 2025 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Jan 07 14:58:26 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 07 14:58:26 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -1, -58, -789672; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 2
LongName: Level 2; Elevation: 3000 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_BuildingStoreyCommon - Reference: 8mm Head
Constraints - Elevation: 3000 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 2; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Intrusion-Products_Bosch_Reader, OSDP, keypad, BLE, black_ARD-SELECT-BOKM:Reader, OSDP, black_ARD-SELECT-BO, Intrusion-Products_Bosch_Reader, OSDP, keypad, BLE, black_ARD-SELECT-BOKM:Reader, OSDP, black_ARD-SELECT-BO:419382
In: Level 2
Type - Material: Body_Gray
Type - Constraints - Crypt_OSDP: no; Default Elevation: 1400 mm
Type - Dimensions - Dimension depth (mm): 35; Dimension height (mm): 88; Dimension width (mm): 101
Type - Electrical - Operating voltage (VDC) (maximum): 30; Operating voltage (VDC) (minimum): 8; Power consumption (VA): 3.50
Type - General - IP Class: IP54; Operating temperature (°C) (maximum): 60; Operating temperature (°C) (minimum): -25
Type - Identity Data - Description: Engineered Solutions - LECTUS select LECTUS select u Compact design u Easy installation u Sabotage monitoring u Numbers and symbols backlighted u Three status LEDs The LECTUS select line consists of two different reader variants, one with keypad and one without keypad.; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/LECTUS_Installation_Manual_enUS_84333123083.pdf; Manufacturer: Bosch Security and Safety Systems; OmniClass Number: 23.85.30.11; OmniClass Title: Access Controls; PlanningTools: N/A; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/LECTUS_select_Data_sheet_enUS_84333059723.pdf; Product Website: https://commerce.boschsecurity.com/nordics/en/LECTUS-select/p/F.01U.389.839/; Type Name: Reader, OSDP, black_ARD-SELECT-BO
Type - Materials and Finishes - Color: Black/silver; Color in RAL: N/A
Type - Other - Category: Security Devices; Family Name: Intrusion-Products_Bosch_Reader, OSDP, keypad, BLE, black_ARD-SELECT-BOKM
Type - Pset_BuildingElementProxyCommon - Reference: Reader, OSDP, black_ARD-SELECT-BO; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: Reader, OSDP, black_ARD-SELECT-BO
Type - Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation from Level: 0 mm; Host: Level : Level 2; Level: Level: Level 2; Schedule Level: Level: Level 2
Construction - ARA-SELECT-SWA Wallmount Box Lectus Select, silver: no; ARA-SELECT-WWA Wallmount Box Lectus Select, white: no
Dimensions - Area: 0.011458 m2; Volume: 0.000152288 m3
Electrical - Circuiting - Electrical Data: 0 V/1-0 VA
Identity Data - CTN: ARD-SELECT-BOKM; Mark: 2; Material number: F.01U.389.851
Other - Family: Intrusion-Products_Bosch_Reader, OSDP, keypad, BLE, black_ARD-SELECT-BOKM: Reader, OSDP, black_ARD-SELECT-BO; Family and Type: Intrusion-Products_Bosch_Reader, OSDP, keypad, BLE, black_ARD-SELECT-BOKM: Reader, OSDP, black_ARD-SELECT-BO; Type: Intrusion-Products_Bosch_Reader, OSDP, keypad, BLE, black_ARD-SELECT-BOKM: Reader, OSDP, black_ARD-SELECT-BO; Type Id: Intrusion-Products_Bosch_Reader, OSDP, keypad, BLE, black_ARD-SELECT-BOKM: Reader, OSDP, black_ARD-SELECT-BO
Phasing - Phase Created: New Construction

# IfcDistributionPort, Port_419382
Description: Flow; FlowDirection: SOURCEANDSINK
